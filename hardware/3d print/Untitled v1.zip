# Autodesk Inventor part: Component16
Saved by Autodesk Inventor 2022.5 (Build 265521000, 521)
## iProperties
Created: 2024-12
Part Number: Component16
Material: Generic
Document SubType Name: Modeling
Designer: AdminForWorker
Density: 1 g/cm^3
Appearance: Default
Title: Component16
Author: AdminForWorker
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
